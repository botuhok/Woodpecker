/*
Convert uint8_t array to pixelart image
*/

#include <stdio.h>
#include <stdint.h>

void arrayToImage(const uint8_t* data, int width, int height) {
  int frames = height/8;
  for(int i = 0, j = 0; j != frames; i += width, ++j){ 
    for (int row = 8; row >= 0; row--) {
      for(int col = 0 + i; col < width + i; ++col){
        uint8_t byte = data[col];
        if (byte & (1 << (7 - row))) printf("#");
        else printf(" ");
      }
      if(row != 0) printf("\n");
    }
  }
}


int main() {
  static const uint8_t pecker[86] = {
    0,1,3,255,255,0,255,33,33,33,33,51,30,30,12,0,0,60,126,126,219,145,145,145,145,147,90,78,12,0,0,60,126,126,195,129,129,129,129,129,66,102,36,0,129,255,255,255,24,60,60,102,231,195,129,129,0,0,60,126,126,219,145,145,145,145,147,90,78,12,0,129,255,255,0,255,33,33,33,97,97,243,158,158,140,0
  };

  static const uint8_t woodpeckerFrame1[128] =
  {0,4,4,12,92,252,252,252,60,62,30,30,14,14,14,12,28,24,120,240,128,0,0,0,0,0,0,0,64,0,32,0,0,0,0,0,0,6,15,48,192,128,0,0,0,0,0,1,3,0,128,192,193,33,33,34,34,34,34,20,20,148,9,40,0,0,0,128,224,120,28,7,11,9,17,48,224,193,1,0,0,0,7,31,248,224,128,0,0,2,0,0,2,0,0,0,224,120,30,7,1,128,64,0,0,128,64,32,24,15,7,0,0,128,192,96,63,31,7,0,0,0,0,0,0,0,0,0,};

  static const uint8_t woodpeckerFrame2[128] =
  {4,12,28,60,252,252,62,62,30,30,14,14,12,12,28,24,112,224,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,15,31,48,64,128,128,0,0,0,2,7,2,0,128,64,33,33,35,34,34,34,20,20,20,8,8,0,0,0,0,0,0,0,224,120,6,1,8,8,8,17,17,226,194,128,0,1,6,30,120,224,128,0,0,0,0,0,0,0,0,0,0,224,56,15,7,0,0,128,64,48,128,64,32,24,15,7,0,128,192,96,56,31,7,0,0,0,0,0,0,0,0,0,};


  arrayToImage(pecker,86, 8);
  arrayToImage(woodpeckerFrame1, 32, 32);
  arrayToImage(woodpeckerFrame2, 32, 32);

  return 0;
}
